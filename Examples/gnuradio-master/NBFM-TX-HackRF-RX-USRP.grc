options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: interpola1
  id: variable
  parameters:
    value: '10'
  states: {}
- name: interpola2
  id: variable
  parameters:
    value: '6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44000'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: samp_rate
    max_dev: 5e3
    quad_rate: samp_rate*interpola1
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: samp_rate*interpola1
    tau: '75e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: interpola1
    quad_rate: samp_rate*interpola1
  states: {state: disabled}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: samp_rate*interpola1
    tau: '75e-6'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/fernando/documentos/instituto/me/radio/ejemplos/gnuradio/EjemplosOK/sorprendente.wav
    repeat: 'True'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Funciona mucho peor con NBFM (se come parte del sonido) que con WBFM. Hay algo de audio underrun, pero casi no se nota
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=000000000000000071c469c82d291f43
    bb_gain0: '20'
    freq0: 433e6
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate*interpola1*interpola2
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*interpola1*interpola2
    fc: '0'
    fftsize: '1024'
    name: '"RX"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*interpola1*interpola2
    fc: '0'
    fftsize: '1024'
    name: '"TX"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*interpola1
    fc: '0'
    fftsize: '1024'
    name: '"Modulated"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_2_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*interpola1
    fc: '0'
    fftsize: '1024'
    name: '"Decimated"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Output"'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: interpola2
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: interpola2
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: 433e6
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '"addr=192.168.2.67"'
    gain0: '20'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate*interpola1*interpola2
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_nbfm_rx_0, '0', qtgui_freq_sink_x_3, '0']
- [analog_nbfm_tx_0, '0', qtgui_freq_sink_x_2, '0']
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_3, '0']
- [analog_wfm_tx_0, '0', qtgui_freq_sink_x_2, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', analog_nbfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [rational_resampler_xxx_1, '0', analog_nbfm_rx_0, '0']
- [rational_resampler_xxx_1, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_freq_sink_x_2_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_1, '0']

metadata:
  file_format: 1
