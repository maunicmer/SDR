options:
  parameters:
    author: Mauro Mercuri
    generate_options: qt_gui
    id: fm_receiver
    output_language: python
    title: FM Receiver
  states: {}

blocks:
- name: down_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: rfgain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '10'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: tuner
  id: variable_qtgui_range
  parameters:
    label: Tuner
    orient: Qt.Horizontal
    start: '88000000'
    step: '20000'
    stop: '108000000'
    value: '99900000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '20'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: down_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '24000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: 100e3
    decim: '8'
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: firdes.WIN_KAISER
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@0
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@0
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '250'
    interp: '24'
    taps: ''
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: tuner
    gain0: rfgain
    gain_mode0: 'False'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: tab0
    label1: tab1
    num_tabs: '2'
  states: {}

connections:
- [analog_wfm_rcv_0, '0', qtgui_sink_x_1, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_2, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_2, '0', audio_sink_0, '0']
- [rational_resampler_xxx_2, '0', audio_sink_0, '1']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
